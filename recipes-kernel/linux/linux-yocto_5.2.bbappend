require linux-yocto-xilinx-versal.inc

KBRANCH_xilinx-versal  = "v5.2/standard/sdkv5.4/xlnx-soc"
